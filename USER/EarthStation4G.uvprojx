# Keil uVision project EarthStation4G.uvprojx, settings and files
target GTS2-TEST-01 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EarthStation4G +hex
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\FWLIB\src;..\SOURCE;..\SOURCE\SYSTEM;..\SOURCE\SYSTEM\delay;..\SOURCE\SYSTEM\sys;..\Middlewares\FreeRTOS;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s core_cm4.h
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS
    ../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group SOURCE
    ../SOURCE/: main.c stm32f4xx_it.c system_stm32f4xx.c usart.c stm32f4xx_conf.h usart.h main.h ec20.h ec20.c rtos.c rtos.h init.c type.h ec20_usart.c ec20_usart.h time.c time.h stm32f4xx.h idle_task.c idle_task.h init.h
  group SYSTEM
    ../SOURCE/SYSTEM/delay/: delay.c
    ../SOURCE/SYSTEM/sys/: sys.c
  group FreeRTOS_Portable
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
